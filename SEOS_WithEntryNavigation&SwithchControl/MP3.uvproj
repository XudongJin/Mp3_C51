# Keil uVision project MP3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: MP3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 UART.c config.asm SEOS.c Directory_Functions_struct.c File_System_v2.c I2C.c Read_Sector.c SDCard.c SPI.c STA013_config.c hardware_delay.c LCD_routines.c SEOS_test.c Switch.c
